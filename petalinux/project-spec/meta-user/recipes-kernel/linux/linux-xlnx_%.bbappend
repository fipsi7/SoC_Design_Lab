SRC_URI += "file://user_2022-02-07-15-29-00.cfg \
            file://user_2022-02-11-15-16-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

